# Keil uVision project tcpip_access.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: access +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\APP;..\..\CMSIS;..\..\STM32F10x_StdPeriph\inc;..\..\BSP;..\..\BSP\enc28j60;..\..\COM;..\..\COM\display;..\..\COM\fonts;..\..\rtos\UCOSII\CONFIG;..\..\rtos\UCOSII\CORE;..\..\rtos\UCOSII\PORT;..\..\network\lwip-1.3.2\src\include;..\..\network\lwip-1.3.2\src\include\ipv4;..\..\network\lwip-1.3.2\contrib;..\..\filesystem\FATFS\src;..\..\filesystem\FATFS\src\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c stm32f10x_it.c access_app.c netconfig.c lwipopts.h stm32f10x_conf.h
  group CMSIS
    ../../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph
    ../../STM32F10x_StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../../BSP/: global.c usart.c led.c key.c SysTick_OS.c delay_tim.c lcd9341_fsmc.c rc522_config.c rc522_function.c switch_device.c
  group BSP/ENC28J60
    ../../BSP/enc28j60/: ENC28J60.C SPI.C
  group COM
    ../../COM/: timer_event.c
    ../../COM/fonts/: font.c
  group uCOSII/CONFIG
    ../../rtos/UCOSII/CONFIG/: includes.h os_cfg.h
  group uCOSII/CORE
    ../../rtos/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group uCOSII/PORT
    ../../rtos/UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group lwip/api
    ../../network/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../../network/lwip-1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
  group lwip/core/ipv4
    ../../network/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/core/snmp
    ../../network/lwip-1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip/netif
    ../../network/lwip-1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group lwip/netif/ppp
    ../../network/lwip-1.3.2/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group lwip/contrib/arch
    ../../network/lwip-1.3.2/contrib/arch/: cc.h perf.h sys_arch.c sys_arch.h
