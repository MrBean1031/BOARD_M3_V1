# Keil uVision project tft_lcd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: TFT_LCD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\APP;..\..\CMSIS;..\..\BSP;..\..\STM32F10x_StdPeriph\inc;..\..\filesystem\FATFS\src;..\..\filesystem\FATFS\src\option;..\..\COM;..\..\COM\fonts;..\..\COM\display
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c stm32f10x_it.c
  group CMSIS
    ../../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph
    ../../STM32F10x_StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../../BSP/: usart.c delay_tim.c global.c key.c lcd9341_fsmc.c led.c spi_flash.c stm32_eval_sdio_sd.c
  group COM
    ../../COM/: timer_event.c
    ../../COM/display/: show_bmp.c
    ../../COM/fonts/: font.c
  group FATFS
    ../../filesystem/FATFS/src/: diskio.c ff.c
    ../../filesystem/FATFS/src/option/: unicode.c
